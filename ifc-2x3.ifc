Properties of the parts of a building model (IFC2X3)

# File
Description: Strahlungstemperaturfühler, Pendel, NTC 47K, 6 m, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9130180, Strahlungstemperaturfühler, Pendel, NTC 47K, 6 m
In: Raum
Description: Der Pendeltemperaturfühler PF dient zur Erfassung der Temperaturen in größeren Räumen. Aufgrund der Kugelform nimmt dieser Fühler die Temperatur aus allen Richtungen des Raumes auf, wodurch bei korrekter Positionierung im Raum ein repräsentatives Messergebnis erzielt wird.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9130180; ModelLabel: PFC 47/6m; GlobalTradeItemNumber: 4050528039156; ProductURL: https://alre.de/produkt_G9130180
Pset_Specification - NominalLength: 0.06 m; NominalWidth: 0.06 m; NominalDepth: 0.06 m; NetWeight: 0.15
Pset_ALRE_ETIM_Properties - Kabellänge: 6; Mit Gehäuse: yes; Art der Spannungsversorgung: ohne; Umgebungstemperatur: -30; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP65; Mit Befestigungsmaterial: no; Einsatzgebiet: Raum; Geeignet für Flüssigkeiten: no; Geeignet für Gase: yes; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Gehäusehöhe: 60; Gehäusebreite: 60; Gehäusetiefe: 60; Geeignet für Deckenmontage: yes; Festes Kabel am Sensor: yes; Geeignet für Luft: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9130180.pdf
